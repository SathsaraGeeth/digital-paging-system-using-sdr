options:
  parameters:
    author: Phaselink
    generate_options: qt_gui
    id: user1
    output_language: python
    title: Paging_system
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.35'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '11100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport threading\nimport queue\nimport time\nimport random\nimport struct\nfrom Crypto.Cipher import AES\nfrom Crypto.Random import get_random_bytes\nfrom Crypto.Util.Padding import pad, unpad\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Mesh Network Packet Communication Block with AES-128 Encryption\n    Handles packet transmission/reception with Stop-and-Wait ARQ and encrypted payloads\n    \"\"\"\n    \n    def __init__(self, node_id=1, p=0.3, timeout=1.0, max_retries=3, encryption_key=None):\n        \"\"\"\n        Arguments:\n            node_id: Unique identifier for this node (1-255)\n            aloha_prob: Transmission probability for ALOHA (0.0-1.0)\n            timeout: ARQ timeout in seconds\n            max_retries: Maximum retransmission attempts\n            encryption_key: 16-byte AES key (hex string or bytes). If None, generates random key.\n        \"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='pagingsystem',\n            in_sig=None,\n            out_sig=None\n        )\n        \n        # Node configuration\n        self.node_id = node_id\n        self.aloha_prob = p\n        self.timeout = timeout\n        self.max_retries = max_retries\n        \n        # AES-128 Encryption setup\n        if encryption_key is None:\n            # Generate random 128-bit (16-byte) key\n            self.encryption_key = get_random_bytes(16)\n            print(f\"[Node {self.node_id}] Generated random AES key: {self.encryption_key.hex()}\")\n        elif isinstance(encryption_key, str):\n            # Convert hex string to bytes\n            self.encryption_key = bytes.fromhex(encryption_key)\n            if len(self.encryption_key) != 16:\n                raise ValueError(\"Encryption key must be 16 bytes (128 bits)\")\n        else:\n            # Assume bytes\n            self.encryption_key = encryption_key\n            if len(self.encryption_key) != 16:\n                raise ValueError(\"Encryption key must be 16 bytes (128 bits)\")\n        \n        # Packet parameters\n        self.PREAMBLE = bytes([0xAA, 0xAA, 0xAA, 0xAA])\n        self.SYNC_WORD = bytes([0x2D, 0xD4])\n        self.MAX_PAYLOAD = 255\n        self.HEADER_SIZE = 8  # preamble(4) + sync(2) + src(1) + dst(1)\n        self.CRC_SIZE = 2\n        self.IV_SIZE = 16  # AES block size for IV\n        \n        # Packet types\n        self.PKT_DATA = 0x01\n        self.PKT_ACK = 0x02\n        \n        # CRC-16 CCITT lookup table\n        self.crc_table = self.generate_crc_table()\n        \n        # State management\n        self.tx_queue = queue.Queue()\n        self.rx_queue = queue.Queue()\n        self.ack_queue = queue.Queue()\n        self.pending_ack = {}\n        self.seq_num_tx = 0\n        self.seq_num_rx = {}\n        self.rx_buffer = bytes()\n        \n        # Statistics\n        self.stats = {\n            'packets_sent': 0,\n            'packets_received': 0,\n            'acks_sent': 0,\n            'acks_received': 0,\n            'retransmissions': 0,\n            'crc_errors': 0,\n            'decryption_errors': 0\n        }\n        \n        # Threading\n        self.running = True\n        self.tx_thread = threading.Thread(target=self.tx_handler)\n        self.rx_thread = threading.Thread(target=self.rx_handler)\n        self.lock = threading.Lock()\n        \n        # Message ports\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_in(pmt.intern('pdu_in'))\n        self.message_port_register_out(pmt.intern('msg_out'))\n        self.message_port_register_out(pmt.intern('pdu_out'))\n        self.message_port_register_out(pmt.intern('feedback'))\n        \n        # Set message handlers\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg_in)\n        self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu_in)\n        \n        # Start threads\n        self.tx_thread.start()\n        self.rx_thread.start()\n        \n        print(f\"[Node {self.node_id}] Initialized with AES-128 encryption - Ready for secure communication\")\n    \n    def encrypt_payload(self, plaintext):\n        \"\"\"\n        Encrypt payload using AES-128 in CBC mode\n        Returns: IV + encrypted_data\n        \"\"\"\n        try:\n            # Generate random IV (Initialization Vector)\n            iv = get_random_bytes(self.IV_SIZE)\n            \n            # Create AES cipher in CBC mode\n            cipher = AES.new(self.encryption_key, AES.MODE_CBC, iv)\n            \n            # Pad plaintext to multiple of 16 bytes (AES block size)\n            padded_plaintext = pad(plaintext, AES.block_size)\n            \n            # Encrypt\n            ciphertext = cipher.encrypt(padded_plaintext)\n            \n            # Return IV + ciphertext (receiver needs IV to decrypt)\n            return iv + ciphertext\n            \n        except Exception as e:\n            print(f\"[Node {self.node_id}] Encryption error: {e}\")\n            return None\n    \n    def decrypt_payload(self, encrypted_data):\n        \"\"\"\n        Decrypt payload using AES-128 in CBC mode\n        encrypted_data format: IV + ciphertext\n        Returns: plaintext\n        \"\"\"\n        try:\n            # Extract IV (first 16 bytes)\n            iv = encrypted_data[:self.IV_SIZE]\n            ciphertext = encrypted_data[self.IV_SIZE:]\n            \n            # Create AES cipher in CBC mode\n            cipher = AES.new(self.encryption_key, AES.MODE_CBC, iv)\n            \n            # Decrypt\n            padded_plaintext = cipher.decrypt(ciphertext)\n            \n            # Remove padding\n            plaintext = unpad(padded_plaintext, AES.block_size)\n            \n            return plaintext\n            \n        except Exception as e:\n            print(f\"[Node {self.node_id}] Decryption error: {e}\")\n            self.stats['decryption_errors'] += 1\n            return None\n    \n    def generate_crc_table(self):\n        \"\"\"Generate CRC-16 CCITT lookup table\"\"\"\n        poly = 0x1021\n        table = []\n        for i in range(256):\n            crc = i << 8\n            for j in range(8):\n                if crc & 0x8000:\n                    crc = ((crc << 1) ^ poly) & 0xFFFF\n                else:\n                    crc = (crc << 1) & 0xFFFF\n            table.append(crc)\n        return table\n    \n    def calculate_crc16(self, data):\n        \"\"\"Calculate CRC-16 CCITT for given data\"\"\"\n        crc = 0xFFFF\n        for byte in data:\n            tbl_idx = ((crc >> 8) ^ byte) & 0xFF\n            crc = ((crc << 8) ^ self.crc_table[tbl_idx]) & 0xFFFF\n        return crc\n    \n    def handle_msg_in(self, msg):\n        \"\"\"Handle incoming messages from GUI/application\"\"\"\n        try:\n            # Handle string messages directly\n            if pmt.is_symbol(msg):\n                # Simple text message format: \"dst_id:message\"\n                text = pmt.symbol_to_string(msg)\n                if ':' in text:\n                    parts = text.split(':', 1)\n                    try:\n                        dst_id = int(parts[0])\n                        data = parts[1].encode()\n                        self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})\n                        print(f\"[Node {self.node_id}] Queued encrypted message to {dst_id}: {parts[1]}\")\n                    except ValueError:\n                        print(f\"[Node {self.node_id}] Invalid destination ID\")\n            \n            # Handle dictionary messages\n            elif pmt.is_dict(msg):\n                meta = pmt.to_python(msg)\n                if 'dst' in meta and 'data' in meta:\n                    dst_id = meta['dst']\n                    data = meta['data'].encode() if isinstance(meta['data'], str) else meta['data']\n                    self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})\n                    print(f\"[Node {self.node_id}] Queued encrypted message to {dst_id}\")\n            \n            # Handle pair messages (PDU format)\n            elif pmt.is_pair(msg):\n                meta = pmt.to_python(pmt.car(msg))\n                data = pmt.to_python(pmt.cdr(msg))\n                if isinstance(meta, dict) and 'dst' in meta:\n                    dst_id = meta['dst']\n                    if isinstance(data, str):\n                        data = data.encode()\n                    elif isinstance(data, list):\n                        data = bytes(data)\n                    self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})\n                    print(f\"[Node {self.node_id}] Queued encrypted message to {dst_id}\")\n                    \n        except Exception as e:\n            print(f\"[Node {self.node_id}] Error handling msg_in: {e}\")\n    \n    def handle_pdu_in(self, pdu):\n        \"\"\"Handle incoming PDUs from demodulator\"\"\"\n        try:\n            # Extract PDU data\n            if pmt.is_pair(pdu):\n                meta = pmt.car(pdu)\n                data = pmt.cdr(pdu)\n                \n                # Convert to bytes\n                if pmt.is_u8vector(data):\n                    print(\"loop run\")\t\n                    rx_bytes = bytes(pmt.u8vector_elements(data))\t\n                    self.rx_queue.put(rx_bytes)\n                elif pmt.is_uniform_vector(data):\n                    # Handle float32 or other vector types\n                    elements = pmt.to_python(data)\n                    # Convert to bytes (assuming 8-bit symbols)\n                    rx_bytes = bytes([int(x) & 0xFF for x in elements])\n                    self.rx_queue.put(rx_bytes)\n                    \n        except Exception as e:\n            print(f\"[Node {self.node_id}] Error handling pdu_in: {e}\")\n    \n    def create_packet(self, dst_id, seq_num, pkt_type, payload=b''):\n        \"\"\"\n        Create a packet with headers, encrypted payload (for DATA packets), and CRC\n        Packet structure:\n        [PREAMBLE][SYNC][SRC][DST][SEQ][TYPE][LEN][ENCRYPTED_PAYLOAD or EMPTY][CRC]\n        For DATA packets: payload is encrypted (includes IV + ciphertext)\n        For ACK packets: no payload, no encryption needed\n        \"\"\"\n        packet = bytearray()\n        \n        # Add preamble and sync word\n        packet.extend(self.PREAMBLE)\n        packet.extend(self.SYNC_WORD)\n        \n        # Process payload based on packet type\n        final_payload = b''\n        if pkt_type == self.PKT_DATA and payload:\n            # Encrypt the payload for DATA packets\n            encrypted_payload = self.encrypt_payload(payload)\n            if encrypted_payload is None:\n                print(f\"[Node {self.node_id}] Failed to encrypt payload\")\n                return None\n            final_payload = encrypted_payload\n        elif pkt_type == self.PKT_ACK:\n            # ACK packets have no payload\n            final_payload = b''\n        \n        # Add header\n        packet.append(self.node_id)          # Source ID\n        packet.append(dst_id)                # Destination ID\n        packet.append(seq_num)               # Sequence number\n        packet.append(pkt_type)              # Packet type\n        packet.append(len(final_payload))    # Payload length (encrypted length for DATA)\n        \n        # Add payload (encrypted for DATA, empty for ACK)\n        if final_payload:\n            packet.extend(final_payload[:self.MAX_PAYLOAD])\n        \n        # Calculate and add CRC16\n        crc_data = bytes(packet[len(self.PREAMBLE) + len(self.SYNC_WORD):])\n        crc_val = self.calculate_crc16(crc_data)\n        packet.extend(struct.pack('>H', crc_val))\n        \n        return bytes(packet)\n    \n    def parse_packet(self, data):\n        \"\"\"Parse received packet and validate CRC\"\"\"\n        try:\n            # Find sync word\n            sync_idx = data.find(self.SYNC_WORD)\n            if sync_idx == -1:\n                return None\n            \n            # Check minimum packet size\n            start_idx = sync_idx + len(self.SYNC_WORD)\n            if len(data) < start_idx + 5 + self.CRC_SIZE:\n                return None\n            \n            # Extract header fields\n            src_id = data[start_idx]\n            dst_id = data[start_idx + 1]\n            seq_num = data[start_idx + 2]\n            pkt_type = data[start_idx + 3]\n            payload_len = data[start_idx + 4]\n            \n            # Check if we have complete packet\n            total_len = start_idx + 5 + payload_len + self.CRC_SIZE\n            if len(data) < total_len:\n                return None\n            \n            # Extract payload and CRC\n            payload = data[start_idx + 5:start_idx + 5 + payload_len]\n            rx_crc = struct.unpack('>H', data[total_len - self.CRC_SIZE:total_len])[0]\n            \n            # Verify CRC\n            crc_data = data[start_idx:total_len - self.CRC_SIZE]\n            calc_crc = self.calculate_crc16(crc_data)\n            \n            if rx_crc != calc_crc:\n                self.stats['crc_errors'] += 1\n                print(f\"[Node {self.node_id}] CRC mismatch (expected: {calc_crc:04X}, got: {rx_crc:04X})\")\n                return None\n            \n            return {\n                'src': src_id,\n                'dst': dst_id,\n                'seq': seq_num,\n                'type': pkt_type,\n                'payload': payload,  # Still encrypted for DATA packets\n                'consumed': total_len\n            }\n        except Exception as e:\n            print(f\"[Node {self.node_id}] Error parsing packet: {e}\")\n            return None\n    \n    def send_sync_burst(self):\n        \"\"\"Send synchronization burst before packet\"\"\"\n        burst = bytes(random.getrandbits(8) for _ in range(256))\n        self.transmit_packet(burst)\n\n    def tx_handler(self):\n        \"\"\"Thread for handling packet transmission with ARQ\"\"\"\n        while self.running:\n            try:\n                # Get message from queue (with timeout for thread safety)\n                try:\n                    msg = self.tx_queue.get(timeout=0.1)\n                except queue.Empty:\n                    continue\n                \n                # ALOHA: Random backoff\n                if random.random() > self.aloha_prob:\n                    backoff_time = random.uniform(0.1, 0.5)\n                    print(f\"[Node {self.node_id}] ALOHA backoff {backoff_time:.2f}s\")\n                    time.sleep(backoff_time)\n                    # Re-queue the message\n                    self.tx_queue.put(msg)\n                    continue\n                \n                # Prepare packet\n                with self.lock:\n                    seq_num = self.seq_num_tx\n                    self.seq_num_tx = (self.seq_num_tx + 1) % 256\n                \n                packet = self.create_packet(\n                    msg['dst'],\n                    seq_num,\n                    msg['type'],\n                    msg.get('data', b'')\n                )\n                \n                if packet is None:\n                    print(f\"[Node {self.node_id}] Failed to create packet\")\n                    continue\n                \n                # Stop-and-Wait ARQ\n                retries = 0\n                ack_received = False\n                \n                while retries < self.max_retries and not ack_received:\n                    # Transmit packet\n                    print(f\"[Node {self.node_id}] TX: Sending encrypted packet seq={seq_num} to node {msg['dst']} (attempt {retries + 1})\")\n                    self.send_sync_burst()\n                    self.transmit_packet(packet)\n                    self.stats['packets_sent'] += 1\n                    \n                    if retries > 0:\n                        self.stats['retransmissions'] += 1\n                    \n                    # Wait for ACK\n                    ack_key = f\"{msg['dst']}_{seq_num}\"\n                    timeout_time = time.time() + self.timeout\n                    \n                    while time.time() < timeout_time:\n                        try:\n                            ack = self.ack_queue.get(timeout=0.1)\n                            if ack['key'] == ack_key:\n                                ack_received = True\n                                self.stats['acks_received'] += 1\n                                print(f\"[Node {self.node_id}] TX: ACK received for seq={seq_num}\")\n                                output = \"TRUE\"\n                                msg = pmt.intern(output)\n                                self.message_port_pub(pmt.intern('feedback'), msg)\n                                break\n                        except queue.Empty:\n                            pass\n                    \n                    if not ack_received:\n                        retries += 1\n                        if retries < self.max_retries:\n                            print(f\"[Node {self.node_id}] TX: Timeout, retry {retries}/{self.max_retries}\")\n                \n                if not ack_received:\n                    print(f\"[Node {self.node_id}] TX: Failed to deliver packet seq={seq_num} after {self.max_retries} attempts\")\n                    output = \"FALSE\"\n                    msg = pmt.intern(output)\n                    self.message_port_pub(pmt.intern('feedback'), msg)\n                    \n            except Exception as e:\n                print(f\"[Node {self.node_id}] TX handler error: {e}\")\n    \n    def rx_handler(self):\n        \"\"\"Thread for handling packet reception\"\"\"\n        while self.running:\n            try:\n                # Get received data\n                try:\n                    rx_data = self.rx_queue.get(timeout=0.1)\n                except queue.Empty:\n                    continue\n                \n                # Add to buffer\n                self.rx_buffer += rx_data\n                \n                # Try to parse packets from buffer\n                while len(self.rx_buffer) > 0:\n                    pkt = self.parse_packet(self.rx_buffer)\n                    \n                    if pkt is None:\n                        # No valid packet found, remove first byte and try again\n                        if len(self.rx_buffer) > 1:\n                            self.rx_buffer = self.rx_buffer[1:]\n                        else:\n                            self.rx_buffer = bytes()\n                        continue\n                    \n                    # Remove processed packet from buffer\n                    self.rx_buffer = self.rx_buffer[pkt['consumed']:]\n                    \n                    # Check if packet is for this node or broadcast\n                    if pkt['dst'] != self.node_id and pkt['dst'] != 0xFF:\n                        print(f\"[Node {self.node_id}] RX: Packet not for us (dst={pkt['dst']})\")\n                        continue\n                    \n                    # Handle based on packet type\n                    if pkt['type'] == self.PKT_DATA:\n                        self.stats['packets_received'] += 1\n                        print(f\"[Node {self.node_id}] RX: Encrypted data packet from node {pkt['src']}, seq={pkt['seq']}\")\n                        \n                        # Decrypt payload\n                        decrypted_payload = self.decrypt_payload(pkt['payload'])\n                        if decrypted_payload is None:\n                            print(f\"[Node {self.node_id}] RX: Failed to decrypt payload - wrong key or corrupted data\")\n                            # Still send ACK to prevent retransmissions\n                            ack_packet = self.create_packet(\n                                pkt['src'],\n                                pkt['seq'],\n                                self.PKT_ACK\n                            )\n                            self.send_sync_burst()\n                            self.transmit_packet(ack_packet)\n                            self.stats['acks_sent'] += 1\n                            continue\n                        \n                        # Check for duplicate\n                        is_duplicate = False\n                        if pkt['src'] in self.seq_num_rx:\n                            if self.seq_num_rx[pkt['src']] == pkt['seq']:\n                                print(f\"[Node {self.node_id}] RX: Duplicate packet detected\")\n                                is_duplicate = True\n                        \n                        self.seq_num_rx[pkt['src']] = pkt['seq']\n                        \n                        # Send ACK\n                        ack_packet = self.create_packet(\n                            pkt['src'],\n                            pkt['seq'],\n                            self.PKT_ACK\n                        )\n                        print(f\"[Node {self.node_id}] RX: Sending ACK for seq={pkt['seq']}\")\n                        self.send_sync_burst()\n                        self.transmit_packet(ack_packet)\n                        self.stats['acks_sent'] += 1\n                        \n                        # Forward to application if not duplicate\n                        if not is_duplicate:\n                            self.forward_to_app(pkt['src'], decrypted_payload)\n                        \n                    elif pkt['type'] == self.PKT_ACK:\n                        print(f\"[Node {self.node_id}] RX: ACK packet from node {pkt['src']}, seq={pkt['seq']}\")\n                        # Process ACK\n                        ack_key = f\"{pkt['src']}_{pkt['seq']}\"\n                        self.ack_queue.put({'key': ack_key})\n                        \n            except Exception as e:\n                print(f\"[Node {self.node_id}] RX handler error: {e}\")\n    \n    def transmit_packet(self, packet):\n        \"\"\"Send packet to physical layer\"\"\"\n        try:\n            # Convert to PDU format\n            vec = pmt.init_u8vector(len(packet), list(packet))\n            pdu = pmt.cons(pmt.PMT_NIL, vec)\n            \n            # Send to modulator\n            self.message_port_pub(pmt.intern('pdu_out'), pdu)\n            \n        except Exception as e:\n            print(f\"[Node {self.node_id}] Error transmitting packet: {e}\")\n    \n    def forward_to_app(self, src_id, data):\n        \"\"\"Forward received decrypted data to application/GUI\"\"\"\n        try:\n            # Decode message\n            message = data.decode('utf-8', errors='ignore')\n            \n            # Create formatted output string\n            output = f\"[From Node {src_id}] [DECRYPTED]: {message}\"\n            \n            # Send as simple string message\n            msg = pmt.intern(output)\n            self.message_port_pub(pmt.intern('msg_out'), msg)\n            \n            # Also send as dictionary for more complex processing\n            meta = pmt.make_dict()\n            meta = pmt.dict_add(meta, pmt.intern(\"src\"), pmt.from_long(src_id))\n            meta = pmt.dict_add(meta, pmt.intern(\"data\"), pmt.intern(message))\n            \n            print(f\"[Node {self.node_id}] Decrypted message delivered: {output}\")\n            \n        except Exception as e:\n            print(f\"[Node {self.node_id}] Error forwarding to app: {e}\")\n    \n    def work(self, input_items, output_items):\n        \"\"\"Main work function (not used for message passing blocks)\"\"\"\n        return 0\n    \n    def stop(self):\n        \"\"\"Clean shutdown\"\"\"\n        print(f\"\\n[Node {self.node_id}] Statistics:\")\n        print(f\"  Packets sent: {self.stats['packets_sent']}\")\n        print(f\"  Packets received: {self.stats['packets_received']}\")\n        print(f\"  ACKs sent: {self.stats['acks_sent']}\")\n        print(f\"  ACKs received: {self.stats['acks_received']}\")\n        print(f\"  Retransmissions: {self.stats['retransmissions']}\")\n        print(f\"  CRC errors: {self.stats['crc_errors']}\")\n        print(f\"  Decryption errors: {self.stats['decryption_errors']}\")\n        \n        self.running = False\n        if self.tx_thread.is_alive():\n            self.tx_thread.join()\n        if self.rx_thread.is_alive():\n            self.rx_thread.join()\n        return True\n"
    comment: vsv x
    encryption_key: b"0123456789abcdef"
    max_retries: '30'
    node_id: '2'
    p: '0.6'
    timeout: '0.3'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import pmt
      from datetime import datetime

      class WallpaperScrollArea(QtWidgets.QScrollArea):
          def __init__(self, parent=None):
              super().__init__(parent)
              self.setWidgetResizable(True)
              self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)


      class _GuiPoster(QtCore.QObject):
          """Helper QObject to post strings into the Qt thread safely."""
          sig = QtCore.pyqtSignal(str)  # emits text payload

          def __init__(self):
              super().__init__()


      class messenger_gui(gr.basic_block):
          """
          WhatsApp-style Messenger GUI (GNU Radio embedded block).
          - Outgoing messages: published on message port "out" with address prepended as "addr:body"
          - Feedback port "feedback": updates delivery timestamp / failed status
          - Incoming messages: received on port "in_msg" (same format "addr:body") and displayed
            on the left in a different color.
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Messeges",
                  in_sig=None,
                  out_sig=None,
              )

              # Message ports
              self.message_port_register_out(pmt.intern("out"))    # outgoing messages
              self.message_port_register_in(pmt.intern("feedback"))# delivery feedback
              self.message_port_register_in(pmt.intern("in_msg"))  # incoming messages from remote/devices

              # Bind handlers
              self.set_msg_handler(pmt.intern("feedback"), self._process_feedback)
              self.set_msg_handler(pmt.intern("in_msg"), self._receive_message)

              # Poster used to safely move messages to GUI thread
              self._poster = _GuiPoster()
              self._poster.sig.connect(self._display_incoming)  # connect to GUI-thread handler

              # Qt Application
              self.app = QtWidgets.QApplication.instance()
              if self.app is None:
                  self.app = QtWidgets.QApplication(sys.argv)

              # Main window with dark theme
              self.qt_widget = QtWidgets.QWidget()
              self.qt_widget.setWindowTitle("Messenger GUI User 2")
              self.qt_widget.resize(680, 600)
              self.qt_widget.setStyleSheet("""
                  QWidget {
                      background-color: #1a1a2e;
                      color: #eaeaea;
                  }
              """)

              main_layout = QtWidgets.QVBoxLayout()
              main_layout.setContentsMargins(0, 0, 0, 0)
              main_layout.setSpacing(0)
              self.qt_widget.setLayout(main_layout)

              # Header bar with receiver input
              header = QtWidgets.QWidget()
              header.setStyleSheet("""
                  QWidget {
                      background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                          stop:0 #6a11cb, stop:1 #2575fc);
                      border-bottom: 2px solid #4a5568;
                  }
              """)
              header.setFixedHeight(70)
              header_layout = QtWidgets.QHBoxLayout()
              header_layout.setContentsMargins(20, 10, 20, 10)
              header.setLayout(header_layout)

              # Receiver label and input
              addr_label = QtWidgets.QLabel("To:")
              addr_label.setStyleSheet("""
                  font-size: 16px;
                  font-weight: bold;
                  color: #ffffff;
                  background: transparent;
              """)
              header_layout.addWidget(addr_label)

              self.addr_box = QtWidgets.QLineEdit()
              self.addr_box.setPlaceholderText("Enter receiver (e.g., userA=1, userB=2)")
              self.addr_box.setText("1")  # Default receiver
              self.addr_box.setFixedWidth(300)
              self.addr_box.setStyleSheet("""
                  QLineEdit {
                      background-color: rgba(255, 255, 255, 0.15);
                      border: 2px solid rgba(255, 255, 255, 0.3);
                      border-radius: 20px;
                      padding: 8px 15px;
                      font-size: 14px;
                      color: #ffffff;
                  }
                  QLineEdit:focus {
                      border: 2px solid #00d4ff;
                      background-color: rgba(255, 255, 255, 0.25);
                  }
                  QLineEdit::placeholder {
                      color: rgba(255, 255, 255, 0.6);
                  }
              """)
              header_layout.addWidget(self.addr_box)
              header_layout.addStretch()

              main_layout.addWidget(header)

              # Scroll area with background
              self.scroll_area = WallpaperScrollArea()
              self.scroll_area.setStyleSheet("""
                  QScrollArea {
                      border: none;
                      background-color: #16213e;
                  }
              """)
              self.scroll_area.setWidgetResizable(True)
              main_layout.addWidget(self.scroll_area)

              # Chat container (vertical list of message widgets)
              self.chat_container = QtWidgets.QWidget()
              self.chat_layout = QtWidgets.QVBoxLayout()
              self.chat_layout.setAlignment(QtCore.Qt.AlignTop)
              self.chat_layout.setSpacing(12)
              self.chat_layout.setContentsMargins(15, 15, 15, 15)
              self.chat_container.setLayout(self.chat_layout)
              self.chat_container.setStyleSheet("background: transparent;")
              self.scroll_area.setWidget(self.chat_container)

              # Input area (text entry + send) with modern styling
              input_container = QtWidgets.QWidget()
              input_container.setStyleSheet("""
                  QWidget {
                      background-color: #0f3460;
                      border-top: 2px solid #4a5568;
                  }
              """)
              input_container.setFixedHeight(80)
              input_layout = QtWidgets.QHBoxLayout()
              input_layout.setContentsMargins(15, 15, 15, 15)
              input_container.setLayout(input_layout)

              self.input_box = QtWidgets.QLineEdit()
              self.input_box.setPlaceholderText("Type your message...")
              self.input_box.setMinimumHeight(45)
              self.input_box.setStyleSheet("""
                  QLineEdit {
                      border: 2px solid #4a5568;
                      border-radius: 22px;
                      padding: 10px 18px;
                      background-color: #1a1a2e;
                      color: #eaeaea;
                      font-size: 15px;
                  }
                  QLineEdit:focus {
                      border: 2px solid #00d4ff;
                      background-color: #252545;
                  }
                  QLineEdit::placeholder {
                      color: #6c757d;
                  }
              """)
              
              self.send_button = QtWidgets.QPushButton("Send")
              self.send_button.setMinimumHeight(45)
              self.send_button.setFixedWidth(100)
              self.send_button.setStyleSheet("""
                  QPushButton {
                      background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                          stop:0 #f093fb, stop:1 #f5576c);
                      color: white;
                      border: none;
                      border-radius: 22px;
                      padding: 10px 20px;
                      font-weight: bold;
                      font-size: 15px;
                  }
                  QPushButton:hover {
                      background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                          stop:0 #fa709a, stop:1 #fee140);
                  }
                  QPushButton:pressed {
                      background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                          stop:0 #d387ab, stop:1 #b8255f);
                  }
              """)
              
              input_layout.addWidget(self.input_box)
              input_layout.addWidget(self.send_button)
              main_layout.addWidget(input_container)

              # Connect GUI signals
              self.send_button.clicked.connect(self.send_message)
              self.input_box.returnPressed.connect(self.send_message)

              # Track last sent message timestamp widget
              self._last_message_timestamp = None

              # show window
              self.qt_widget.show()

          def send_message(self):
              """Called from GUI thread when user presses Send or Enter."""
              text = self.input_box.text().strip()
              if not text:
                  return

              addr = self.addr_box.text().strip()
              if not addr:
                  addr = "1"  # Default to 1 if empty
                  
              full_msg = f"{addr}:{text}"

              # Publish as PMT symbol/string on 'out' port
              try:
                  self.message_port_pub(pmt.intern("out"), pmt.intern(full_msg))
              except Exception:
                  # fallback to generic intern
                  self.message_port_pub(pmt.intern("out"), pmt.intern(full_msg))

              # Build outgoing bubble (right side)
              container = QtWidgets.QWidget()
              container.setStyleSheet("background: transparent;")
              vbox = QtWidgets.QVBoxLayout()
              vbox.setContentsMargins(0, 0, 0, 0)
              vbox.setSpacing(4)

              # Scrollable area for long messages
              scroll = QtWidgets.QScrollArea()
              scroll.setWidgetResizable(True)
              scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)
              scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
              scroll.setStyleSheet("background: transparent; border: none;")

              bubble = QtWidgets.QLabel(text)
              bubble.setWordWrap(False)
              bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              bubble.setStyleSheet("""
                  QLabel {
                      background: qlineargradient(x1:0, y1:0, x2:1, y2:1,
                          stop:0 #667eea, stop:1 #764ba2);
                      color: #ffffff;
                      border-radius: 18px;
                      padding: 12px 16px;
                      font-size: 14px;
                  }
              """)
              
              # Shadow effect
              effect = QtWidgets.QGraphicsDropShadowEffect()
              effect.setBlurRadius(10)
              effect.setXOffset(0)
              effect.setYOffset(3)
              effect.setColor(QtGui.QColor(0, 0, 0, 100))
              bubble.setGraphicsEffect(effect)

              scroll.setWidget(bubble)
              scroll.setMinimumWidth(160)
              scroll.setMaximumWidth(520)

              # Timestamp pill
              timestamp = QtWidgets.QLabel("Sending...")
              timestamp.setStyleSheet("""
                  QLabel {
                      background-color: rgba(0, 212, 255, 0.3);
                      color: #00d4ff;
                      font-size: 10px;
                      border-radius: 10px;
                      padding: 3px 8px;
                  }
              """)
              timestamp.setAlignment(QtCore.Qt.AlignRight)
              timestamp.setSizePolicy(QtWidgets.QSizePolicy.Fixed, QtWidgets.QSizePolicy.Fixed)

              vbox.addWidget(scroll, alignment=QtCore.Qt.AlignRight)
              vbox.addWidget(timestamp, alignment=QtCore.Qt.AlignRight)
              container.setLayout(vbox)
              container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)

              # Add to chat layout
              self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignRight)

              # Force layout update and scroll to bottom
              bubble.adjustSize()
              scroll.adjustSize()
              container.adjustSize()
              self.chat_container.adjustSize()
              QtWidgets.QApplication.processEvents()
              QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()
              ))

              # Clear input and store timestamp widget
              self.input_box.clear()
              self._last_message_timestamp = timestamp

          def _process_feedback(self, msg_pmt):
              """
              Handler for 'feedback' port. Expected feedback values:
                - "TRUE" => show delivery time
                - "FALSE" => show 'Failed'
              """
              try:
                  if pmt.is_symbol(msg_pmt) or pmt.is_string(msg_pmt):
                      fb = pmt.symbol_to_string(msg_pmt)
                  else:
                      py = pmt.to_python(msg_pmt)
                      fb = str(py)
              except Exception:
                  fb = "<unreadable feedback>"

              print(fb)
              # Update last timestamp widget
              if self._last_message_timestamp:
                  if fb == "TRUE":
                      self._last_message_timestamp.setText(datetime.now().strftime("%H:%M:%S"))
                      self._last_message_timestamp.setStyleSheet("""
                          QLabel {
                              background-color: rgba(76, 175, 80, 0.3);
                              color: #4caf50;
                              font-size: 10px;
                              border-radius: 10px;
                              padding: 3px 8px;
                          }
                      """)
                  elif fb == "FALSE":
                      self._last_message_timestamp.setText("Failed")
                      self._last_message_timestamp.setStyleSheet("""
                          QLabel {
                              background-color: rgba(244, 67, 54, 0.3);
                              color: #f44336;
                              font-size: 10px;
                              border-radius: 10px;
                              padding: 3px 8px;
                          }
                      """)

          def _receive_message(self, msg_pmt):
              """
              Handler for 'in_msg' port. Extracts string and posts it to GUI thread.
              """
              try:
                  if pmt.is_symbol(msg_pmt) or pmt.is_string(msg_pmt):
                      s = pmt.symbol_to_string(msg_pmt)
                  else:
                      py = pmt.to_python(msg_pmt)
                      s = str(py)
              except Exception:
                  s = "<unreadable message>"

              # Post to GUI-thread handler
              try:
                  self._poster.sig.emit(s)
              except Exception:
                  try:
                      self._display_incoming(s)
                  except Exception:
                      print("[messenger_gui] failed to deliver incoming message to GUI:", s)

          def _display_incoming(self, full_msg):
              """
              Build incoming bubble (left aligned). full_msg expected in "addr:body" format.
              """
              # Split "addr:body"
              if ":" in full_msg:
                  addr, body = full_msg.split(":", 1)
                  display_text = f"{body}"
                  header_text = f"{addr}"
              else:
                  display_text = full_msg
                  header_text = ""

              container = QtWidgets.QWidget()
              container.setStyleSheet("background: transparent;")
              vbox = QtWidgets.QVBoxLayout()
              vbox.setContentsMargins(0, 0, 0, 0)
              vbox.setSpacing(4)

              # Small header with sender address
              if header_text:
                  header = QtWidgets.QLabel(header_text)
                  header.setStyleSheet("""
                      font-size: 11px;
                      color: #00d4ff;
                      background: transparent;
                      font-weight: bold;
                  """)
                  header.setAlignment(QtCore.Qt.AlignLeft)
                  vbox.addWidget(header, alignment=QtCore.Qt.AlignLeft)

              scroll = QtWidgets.QScrollArea()
              scroll.setWidgetResizable(True)
              scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)
              scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
              scroll.setStyleSheet("background: transparent; border: none;")

              bubble = QtWidgets.QLabel(display_text)
              bubble.setWordWrap(False)
              bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              bubble.setStyleSheet("""
                  QLabel {
                      background: qlineargradient(x1:0, y1:0, x2:1, y2:1,
                          stop:0 #2c3e50, stop:1 #34495e);
                      color: #ecf0f1;
                      border-radius: 18px;
                      padding: 12px 16px;
                      font-size: 14px;
                      border: 1px solid #4a5568;
                  }
              """)

              scroll.setWidget(bubble)
              scroll.setMinimumWidth(160)
              scroll.setMaximumWidth(520)

              vbox.addWidget(scroll, alignment=QtCore.Qt.AlignLeft)

              container.setLayout(vbox)
              container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)

              self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignLeft)

              # Update layout and scroll to bottom
              bubble.adjustSize()
              scroll.adjustSize()
              container.adjustSize()
              self.chat_container.adjustSize()
              QtWidgets.QApplication.processEvents()
              QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()
              ))
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '9000'
    center_freq: 1.2e9
    gain: '60'
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 0.9e9
    gain: '60'
    samp_rate: samp_rate*2
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_repack_bits_bb_1_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [epy_block_0, feedback, epy_block_0_1, feedback]
- [epy_block_0, msg_out, epy_block_0_1, in_msg]
- [epy_block_0, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_block_0_1, out, epy_block_0, msg_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_0, pdu_in]
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
