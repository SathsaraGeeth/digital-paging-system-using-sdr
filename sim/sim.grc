options:
  parameters:
    author: Phaselink
    generate_options: qt_gui
    id: user1
    output_language: python
    title: Paging_system
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.35'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '11100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_linear_equalizer_0_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |-
      from collections import deque
      from Crypto.Cipher import AES
      from Crypto.Random import get_random_bytes
      import zlib
      import time
      import threading
      import sys

      class Node:
          def __init__(self, ID, key, timeout, verbose = False): # key must be 16 bytes, ID 0-255
              self.ID = ID
              self.key = key
              self.timeout = timeout
              
              # format [dest, src, payload]
              self.Uqueue_tx = deque()
              self.Uqueue_rx = deque()
              
              # format [CRC32, ACK?, num, dest, src, payload] num = SN or RN
              self.Lqueue_tx = deque()
              self.Lqueue_txACK = deque() # payload = None as we not doing piggybacking currently
              self.Lqueue_rx = deque()

              # fsm
              self.RNt = 0
              self.SNt = 0
              
              self.RNr = 0
              self.SNr = 0
              self.ACKr = 0


              self._arq_thread = threading.Thread(target=self._StopWaitARQ, daemon=True)
              self._arq_thread.start()
              self._log = threading.Thread(target=self._log_loop, daemon=True) # deamon??
              if verbose: self._log.start()

          def enqueueMsgTX(self, dest, msg):    # dest/ID: int, msg: string
              encrypted = self._encrypt(msg)
              packet = [dest, self.ID] + list(encrypted)
              self.Uqueue_tx.append(packet)
          
          def dequeMsgRX(self):
              if self.Uqueue_rx:
                  packet = self.Uqueue_rx.popleft()
                  # dest = packet[0]
                  src = packet[1]
                  payload_bytes = bytes(packet[2:])
                  decrypted_msg = self._decrypt(payload_bytes)
                  return src, decrypted_msg # src, decrypted msg
                  # return src, payload_bytes
              else:
                  return None

          def TXPacket(self):
              if self.Lqueue_txACK:
                  return self.Lqueue_txACK.popleft()
              elif self.Lqueue_tx:
                  return self.Lqueue_tx.popleft()
              else:
                  return None
              
          def RXPacket(self, packet):
              self.Lqueue_rx.append(packet)


          ########################### Helper Methods ###########################

          # def _StopWaitARQ(self):
          #     packetinTX = None
          #     timer = 0
          #     while True:
          #         # rx + ACK details
          #         if self.Lqueue_rx:
          #             packetinRX = self._checkCRC(self.Lqueue_rx.popleft())
          #             try:
          #                 src = packetinRX[3]
          #             except: src = 0x01
          #             if packetinRX: # CRC pass?
          #                 self.ACKr = packetinRX[0] # ack?
          #                 if self.ACKr != 0: # a ack
          #                     self.RNt = packetinRX[1]
          #                     print(f"{self.ID}:recieved ACK.")
          #                 if self.ACKr == 0: # a msg
          #                     print(f"{self.ID}:recieved msg.")
          #                     self.SNr = packetinRX[1]
          #                     if self.SNr == self.RNr:
          #                         self.RNr += 1
          #                         self.Uqueue_rx.append(packetinRX[2:])
          #                         ACKpacket = self._appendCRC([1, self.RNr, src, self.ID])
          #                         self.Lqueue_txACK.append(ACKpacket)
          #                         print(f"{self.ID}:sent an ACK.")
          #             else:
          #                 NACKpacket = self._appendCRC([111, self.RNr, src, self.ID])
          #                 self.Lqueue_txACK.append(NACKpacket)
                          
          #         # tx details
          #         if (self.SNt == 0) or (self.RNt >= self.SNt):
          #             if self.Uqueue_tx:
          #                 packetinTX = self._appendCRC([0]+[self.SNt]+self.Uqueue_tx.popleft()) # not an ACK, SN?
          #                 print(f"{self.ID}:tx a packet.")
          #                 self.Lqueue_tx.append(packetinTX)
          #                 timer = 0
          #                 self.SNt += 1
          #         else:
          #             if self.ACKr == 111:
          #                 self.Lqueue_tx.append(packetinTX)
          #                 timer = 0
          #             elif timer > 5:  # replace with a real timer
          #                 print(f"{self.ID}:retransmitt a packet.")
          #                 self.Lqueue_tx.append(packetinTX)
          #                 timer = 0
          #             else:
          #                 pass # wait for ACK and noop until timer runs out
          #                 timer += 1
          #         time.sleep(0.01)

          def _StopWaitARQ(self):
              current_tx_packet = None
              tx_sent_time = 0.0
              while True:
                  while self.Lqueue_rx:
                      raw = self.Lqueue_rx.popleft()
                      packetinRX = self._checkCRC(raw)
                      if not packetinRX:
                          try:
                              src_from_raw = raw[7]
                          except Exception:
                              src_from_raw = None
                          if src_from_raw is not None:
                              nack = self._appendCRC([111, self.RNr, src_from_raw, self.ID])
                              self.Lqueue_txACK.append(nack)
                              print(f"{self.ID}: CRC Failed -> Sending NACK")
                          continue
                      ack = packetinRX[0]
                      num = packetinRX[1]
                      dest = packetinRX[2]
                      src  = packetinRX[3]
                      payload = packetinRX[4:]
                      if ack != 0:
                          if ack == 111:
                              print(f"{self.ID}: Received NACK -> Will Retransmit")
                              if current_tx_packet is not None:
                                  tx_sent_time = 0.0
                          else:
                              last_sent_sn = (self.SNt - 1) if self.SNt > 0 else 0
                              if num == last_sent_sn or num == self.RNt:
                                  print(f"{self.ID}: Received ACK({num})")
                                  current_tx_packet = None
                                  tx_sent_time = 0.0
                                  self.RNt = num
                                  self.ACKr = ack
                      else:
                          print(f"{self.ID}: Received MSG({num}) from {src}")
                          self.SNr = num
                          if self.SNr == self.RNr:
                              self.RNr += 1
                              self.Uqueue_rx.append([dest, src] + payload)
                              ACKpacket = self._appendCRC([1, self.SNr, src, self.ID])
                              print(f"{self.ID}: Sending ACK({self.SNr})")
                              self.Lqueue_txACK.append(ACKpacket)
                          else:
                              ack_num = max(0, self.RNr - 1)
                              ACKpacket = self._appendCRC([1, ack_num, src, self.ID])
                              print(f"{self.ID}: Out-of-order MSG -> Sending ACK({ack_num})")
                              self.Lqueue_txACK.append(ACKpacket)
                  if self.Lqueue_txACK:
                      print(f"{self.ID}: Transmitting ACK/NACK Frame")
                      self.Lqueue_tx.append(self.Lqueue_txACK.popleft())
                  if current_tx_packet is None and self.Uqueue_tx:
                      payload_frame = self.Uqueue_tx.popleft()
                      current_tx_packet = self._appendCRC([0, self.SNt] + payload_frame)
                      print(f"{self.ID}: Transmitting MSG({self.SNt})")
                      self.Lqueue_tx.append(current_tx_packet)
                      tx_sent_time = time.time()
                      self.SNt += 1
                  if current_tx_packet is not None:
                      if time.time() - tx_sent_time > self.timeout:
                          print(f"{self.ID}: TIMEOUT -> Retransmitting MSG")
                          self.Lqueue_tx.append(current_tx_packet)
                          tx_sent_time = time.time()
                  time.sleep(0.005)
          

          def _encrypt(self, msg):
              data = msg.encode('utf-8')
              pad_len = 16 - (len(data) % 16)
              padded = data + bytes([pad_len]) * pad_len
              iv = get_random_bytes(16)
              cipher = AES.new(self.key, AES.MODE_CBC, iv)
              ciphertext = cipher.encrypt(padded)

              return iv + ciphertext
          
          def _decrypt(self, encrypted_bytes):
              if isinstance(encrypted_bytes, list):
                  encrypted_bytes = bytes(encrypted_bytes)

              iv = encrypted_bytes[:16]
              ciphertext = encrypted_bytes[16:]
              cipher = AES.new(self.key, AES.MODE_CBC, iv)
              padded_plaintext = cipher.decrypt(ciphertext)
              pad_len = padded_plaintext[-1]
              if pad_len < 1 or pad_len > 16:
                  raise ValueError("Invalid padding")
              plaintext = padded_plaintext[:-pad_len]
              return plaintext.decode('utf-8')

          def _appendCRC(self, packet): # packet = [ack, num, dest, src, payload...]
              ack = packet[0]
              num = packet[1]
              dest = packet[2]
              src = packet[3]
              payload = packet[4:]
              payload_bytes = bytes(payload)
              data = bytes([ack, num, dest, src]) + payload_bytes
              crc = zlib.crc32(data)
              crc = [(crc >> 24) & 0xFF, (crc >> 16) & 0xFF, (crc >> 8) & 0xFF, crc & 0xFF]

              return crc + [ack, num, dest, src] + payload
          
          def _checkCRC(self, packet): # [CRC0, CRC1, CRC2, CRC3, ack, num, dest, src, payload...]
              crc_recv = ((packet[0] << 24) | (packet[1] << 16) | (packet[2] << 8) | packet[3])
              ack  = packet[4]
              num  = packet[5]
              dest = packet[6]
              src  = packet[7]
              payload = packet[8:]
              payload_bytes = bytes(payload)
              data = bytes([ack, num, dest, src]) + payload_bytes
              crc_calc = zlib.crc32(data)
              if crc_calc == crc_recv:
                  return [ack, num, dest, src] + payload
              else:
                  return False
          
          def _log_loop(self):
                  while True:
                      self.print_status()
                      time.sleep(0.5)

          def print_status(self):
              print(f"Node ID: {self.ID}")
              print(f"Key: {self.key}")
              print(f"Uqueue_tx: {list(self.Uqueue_tx)}")
              print(f"Uqueue_rx: {list(self.Uqueue_rx)}")
              print(f"Lqueue_tx: {list(self.Lqueue_tx)}")
              print(f"Lqueue_txACK: {list(self.Lqueue_txACK)}")
              print(f"Lqueue_rx: {list(self.Lqueue_rx)}")
              print(f"SNt: {self.SNt}, RNt: {self.RNt}")
              print(f"SNr: {self.SNr}, RNr: {self.RNr}")
              print(f"ACKr: {self.ACKr}")
              print("--------------------------------------------------")
              

      # SIMPLE GUI


      # from gnuradio import gr
      # import pmt
      # import threading
      # import queue
      # import time
      # from PyQt5 import QtWidgets, QtCore


      # class Messages(gr.basic_block):
      #     def __init__(self, nodeID=0x00, timeout = 1, key=b"0123456789abcdef"):
      #         gr.basic_block.__init__(self,
      #                                name="Messages",
      #                                in_sig=None,
      #                                out_sig=None)
      #         self.node = Node(nodeID, key, timeout, False)

      #         self.message_port_register_in(pmt.intern("in"))
      #         self.message_port_register_out(pmt.intern("out"))
      #         self.set_msg_handler(pmt.intern("in"), self.rx_from_phy)

      #         self.app = QtWidgets.QApplication.instance() or QtWidgets.QApplication([])
      #         self.window = self.GuiWindow(self)
      #         self.window.show()

      #         self.timer = QtCore.QTimer()
      #         self.timer.timeout.connect(self.poll_node)
      #         self.timer.start(10) #50

      #     def rx_from_phy(self, pdu):
      #         payload = list(pmt.u8vector_elements(pmt.cdr(pdu)))
      #         self.node.RXPacket(payload)

      #     def poll_node(self):
      #         while True:
      #             pkt = self.node.TXPacket()
      #             if pkt:
      #                 payload_pmt = pmt.init_u8vector(len(pkt), pkt)
      #                 pdu = pmt.cons(pmt.PMT_NIL, payload_pmt)
      #                 self.message_port_pub(pmt.intern("out"), pdu)
      #             else:
      #                 break

      #         while True:
      #             msg = self.node.dequeMsgRX()
      #             if not msg:
      #                 break
      #             src, msg_text = msg
      #             self.window.append_message(src, msg_text)

      #     class GuiWindow(QtWidgets.QWidget):
      #         def __init__(self, block):
      #             super().__init__()
      #             self.block = block
      #             self.setWindowTitle(f"Messages(ID={block.node.ID})")
      #             self.resize(650, 450)
      #             layout = QtWidgets.QVBoxLayout(self)

      #             self.text_incoming = QtWidgets.QTextEdit()
      #             self.text_incoming.setReadOnly(True)
      #             layout.addWidget(self.text_incoming)

      #             hl = QtWidgets.QHBoxLayout()
      #             hl.addWidget(QtWidgets.QLabel("Dest ID:"))
      #             self.dest_spin = QtWidgets.QSpinBox()
      #             self.dest_spin.setRange(0, 255)
      #             hl.addWidget(self.dest_spin)

      #             self.input_line = QtWidgets.QLineEdit()
      #             hl.addWidget(self.input_line, stretch=1)

      #             self.send_btn = QtWidgets.QPushButton("Send")
      #             hl.addWidget(self.send_btn)
      #             layout.addLayout(hl)

      #             self.send_btn.clicked.connect(self.send_message)
      #             self.input_line.returnPressed.connect(self.send_message)

      #         def send_message(self):
      #             msg = self.input_line.text().strip()
      #             if not msg:
      #                 return
      #             dest = self.dest_spin.value()
      #             self.block.node.enqueueMsgTX(dest, msg)
      #             self.input_line.clear()

      #         def append_message(self, src, msg):
      #             self.text_incoming.append(f"[From {src}] {msg}")




      from gnuradio import gr
      import pmt
      from PyQt5 import QtWidgets, QtCore, QtGui
      from datetime import datetime

      class Messages(gr.basic_block):
          def __init__(self, nodeID=0x00, timeout=1, key=b"0123456789abcdef"):
              super().__init__(name="Messages", in_sig=None, out_sig=None)
              self.node = Node(nodeID, key, timeout, False)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.rx_from_phy)

              self.app = QtWidgets.QApplication.instance() or QtWidgets.QApplication([])

              self.window = self.GuiWindow(self)
              self.window.show()

              self.timer = QtCore.QTimer()
              self.timer.timeout.connect(self.poll_node)
              self.timer.start(10)

          def rx_from_phy(self, pdu):
              payload = list(pmt.u8vector_elements(pmt.cdr(pdu)))
              self.node.RXPacket(payload)

          def poll_node(self):
              while True:
                  pkt = self.node.TXPacket()
                  if pkt:
                      payload_pmt = pmt.init_u8vector(len(pkt), pkt)
                      pdu = pmt.cons(pmt.PMT_NIL, payload_pmt)
                      self.message_port_pub(pmt.intern("out"), pdu)
                  else:
                      break

              while True:
                  msg = self.node.dequeMsgRX()
                  if not msg:
                      break
                  src, msg_text = msg
                  self.window.append_message(str(src), msg_text)


          class GuiWindow(QtWidgets.QWidget):
              def __init__(self, block):
                  super().__init__()
                  self.block = block
                  self.setWindowTitle(f"Messeges. User: {block.node.ID}")
                  self.resize(680, 600)
                  self.setStyleSheet("""
                      QWidget { background-color: #1a1a2e; color: #eaeaea; }
                  """)

                  main_layout = QtWidgets.QVBoxLayout(self)
                  main_layout.setContentsMargins(0,0,0,0)
                  main_layout.setSpacing(0)

                  header = QtWidgets.QWidget()
                  header.setStyleSheet("""
                      QWidget {
                          background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                              stop:0 #6a11cb, stop:1 #2575fc);
                          border-bottom: 2px solid #4a5568;
                      }
                  """)
                  header.setFixedHeight(70)
                  hl = QtWidgets.QHBoxLayout(header)
                  hl.setContentsMargins(20, 10, 20, 10)

                  label = QtWidgets.QLabel("To:")
                  label.setStyleSheet("font-size:16px; font-weight:bold; color:white;")
                  hl.addWidget(label)

                  self.dest_input = QtWidgets.QLineEdit()
                  self.dest_input.setPlaceholderText("Enter receiver (0-255)")
                  self.dest_input.setText(str(block.node.ID))
                  self.dest_input.setFixedWidth(300)
                  self.dest_input.setStyleSheet("""
                      QLineEdit {
                          background-color: rgba(255,255,255,0.15);
                          border: 2px solid rgba(255,255,255,0.3);
                          border-radius: 20px;
                          padding: 8px 15px;
                          font-size: 14px;
                          color: #ffffff;
                      }
                      QLineEdit:focus {
                          border: 2px solid #00d4ff;
                          background-color: rgba(255,255,255,0.25);
                      }
                  """)
                  hl.addWidget(self.dest_input)
                  hl.addStretch()

                  main_layout.addWidget(header)

                  self.scroll_area = QtWidgets.QScrollArea()
                  self.scroll_area.setWidgetResizable(True)
                  self.scroll_area.setStyleSheet("background-color:#16213e; border:none;")
                  main_layout.addWidget(self.scroll_area)

                  self.chat_container = QtWidgets.QWidget()
                  self.chat_layout = QtWidgets.QVBoxLayout(self.chat_container)
                  self.chat_layout.setAlignment(QtCore.Qt.AlignTop)
                  self.chat_layout.setSpacing(12)
                  self.chat_layout.setContentsMargins(15,15,15,15)
                  self.scroll_area.setWidget(self.chat_container)


                  input_bar = QtWidgets.QWidget()
                  input_bar.setFixedHeight(80)
                  input_bar.setStyleSheet("background-color:#0f3460; border-top:2px solid #4a5568;")
                  ib = QtWidgets.QHBoxLayout(input_bar)
                  ib.setContentsMargins(15,15,15,15)

                  self.input_line = QtWidgets.QLineEdit()
                  self.input_line.setPlaceholderText("Type your message...")
                  self.input_line.setStyleSheet("""
                      QLineEdit {
                          border: 2px solid #4a5568;
                          border-radius: 22px;
                          padding: 10px 18px;
                          background-color: #1a1a2e;
                          color: #eaeaea;
                          font-size: 15px;
                      }
                      QLineEdit:focus {
                          border: 2px solid #00d4ff;
                          background-color: #252545;
                      }
                  """)

                  self.send_btn = QtWidgets.QPushButton("Send")
                  self.send_btn.setFixedWidth(100)
                  self.send_btn.setStyleSheet("""
                      QPushButton {
                          background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                              stop:0 #f093fb, stop:1 #f5576c);
                          color: white;
                          border: none;
                          border-radius: 22px;
                          padding: 10px 20px;
                          font-weight: bold;
                          font-size: 15px;
                      }
                      QPushButton:hover {
                          background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                              stop:0 #fa709a, stop:1 #fee140);
                      }
                  """)

                  ib.addWidget(self.input_line)
                  ib.addWidget(self.send_btn)
                  main_layout.addWidget(input_bar)

                  self.send_btn.clicked.connect(self.send_message)
                  self.input_line.returnPressed.connect(self.send_message)


              def send_message(self):
                  text = self.input_line.text().strip()
                  if not text:
                      return

                  try:
                      dest = int(self.dest_input.text().strip())
                  except:
                      dest = 0

                  self.block.node.enqueueMsgTX(dest, text)
                  self.input_line.clear()

                  self._add_bubble(text, outgoing=True)


              def append_message(self, src, msg):
                  self._add_bubble(f"{msg}", sender=src, outgoing=False)


              def _add_bubble(self, text, sender=None, outgoing=False):
                  container = QtWidgets.QWidget()
                  container.setStyleSheet("background:transparent;")
                  vbox = QtWidgets.QVBoxLayout(container)
                  vbox.setContentsMargins(0,0,0,0)
                  vbox.setSpacing(4)

                  if sender is not None:
                      lab = QtWidgets.QLabel(str(sender))
                      lab.setStyleSheet("font-size:11px; color:#00d4ff; font-weight:bold;")
                      vbox.addWidget(lab, alignment=QtCore.Qt.AlignLeft)

                  scroll = QtWidgets.QScrollArea()
                  scroll.setWidgetResizable(True)
                  scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
                  scroll.setStyleSheet("background:transparent; border:none;")

                  bubble = QtWidgets.QLabel(text)
                  bubble.setWordWrap(False)
                  bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)

                  if outgoing:
                      bubble.setStyleSheet("""
                          QLabel {
                              background: qlineargradient(x1:0, y1:0, x2:1, y2:1,
                                  stop:0 #667eea, stop:1 #764ba2);
                              color: #ffffff;
                              border-radius: 18px;
                              padding: 12px 16px;
                              font-size: 14px;
                          }
                      """)
                  else:
                      bubble.setStyleSheet("""
                          QLabel {
                              background: qlineargradient(x1:0, y1:0, x2:1, y2:1,
                                  stop:0 #2c3e50, stop:1 #34495e);
                              color: #ecf0f1;
                              border-radius: 18px;
                              padding: 12px 16px;
                              font-size: 14px;
                              border: 1px solid #4a5568;
                          }
                      """)

                  scroll.setWidget(bubble)
                  scroll.setMinimumWidth(160)
                  scroll.setMaximumWidth(520)

                  align = QtCore.Qt.AlignRight if outgoing else QtCore.Qt.AlignLeft
                  vbox.addWidget(scroll, alignment=align)

                  self.chat_layout.addWidget(container, alignment=align)

                  QtWidgets.QApplication.processEvents()
                  QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                      self.scroll_area.verticalScrollBar().maximum()))
    key: b"0123456789abcdef"
    nodeID: '0x00'
    timeout: '0.01'
  states: {}
- name: epy_block_0_1_0_0
  id: epy_block
  parameters:
    _source_code: |-
      from collections import deque
      from Crypto.Cipher import AES
      from Crypto.Random import get_random_bytes
      import zlib
      import time
      import threading
      import sys

      class Node:
          def __init__(self, ID, key, timeout, verbose = False): # key must be 16 bytes, ID 0-255
              self.ID = ID
              self.key = key
              self.timeout = timeout
              
              # format [dest, src, payload]
              self.Uqueue_tx = deque()
              self.Uqueue_rx = deque()
              
              # format [CRC32, ACK?, num, dest, src, payload] num = SN or RN
              self.Lqueue_tx = deque()
              self.Lqueue_txACK = deque() # payload = None as we not doing piggybacking currently
              self.Lqueue_rx = deque()

              # fsm
              self.RNt = 0
              self.SNt = 0
              
              self.RNr = 0
              self.SNr = 0
              self.ACKr = 0


              self._arq_thread = threading.Thread(target=self._StopWaitARQ, daemon=True)
              self._arq_thread.start()
              self._log = threading.Thread(target=self._log_loop, daemon=True) # deamon??
              if verbose: self._log.start()

          def enqueueMsgTX(self, dest, msg):    # dest/ID: int, msg: string
              encrypted = self._encrypt(msg)
              packet = [dest, self.ID] + list(encrypted)
              self.Uqueue_tx.append(packet)
          
          def dequeMsgRX(self):
              if self.Uqueue_rx:
                  packet = self.Uqueue_rx.popleft()
                  # dest = packet[0]
                  src = packet[1]
                  payload_bytes = bytes(packet[2:])
                  decrypted_msg = self._decrypt(payload_bytes)
                  return src, decrypted_msg # src, decrypted msg
                  # return src, payload_bytes
              else:
                  return None

          def TXPacket(self):
              if self.Lqueue_txACK:
                  return self.Lqueue_txACK.popleft()
              elif self.Lqueue_tx:
                  return self.Lqueue_tx.popleft()
              else:
                  return None
              
          def RXPacket(self, packet):
              self.Lqueue_rx.append(packet)


          ########################### Helper Methods ###########################

          # def _StopWaitARQ(self):
          #     packetinTX = None
          #     timer = 0
          #     while True:
          #         # rx + ACK details
          #         if self.Lqueue_rx:
          #             packetinRX = self._checkCRC(self.Lqueue_rx.popleft())
          #             try:
          #                 src = packetinRX[3]
          #             except: src = 0x01
          #             if packetinRX: # CRC pass?
          #                 self.ACKr = packetinRX[0] # ack?
          #                 if self.ACKr != 0: # a ack
          #                     self.RNt = packetinRX[1]
          #                     print(f"{self.ID}:recieved ACK.")
          #                 if self.ACKr == 0: # a msg
          #                     print(f"{self.ID}:recieved msg.")
          #                     self.SNr = packetinRX[1]
          #                     if self.SNr == self.RNr:
          #                         self.RNr += 1
          #                         self.Uqueue_rx.append(packetinRX[2:])
          #                         ACKpacket = self._appendCRC([1, self.RNr, src, self.ID])
          #                         self.Lqueue_txACK.append(ACKpacket)
          #                         print(f"{self.ID}:sent an ACK.")
          #             else:
          #                 NACKpacket = self._appendCRC([111, self.RNr, src, self.ID])
          #                 self.Lqueue_txACK.append(NACKpacket)
                          
          #         # tx details
          #         if (self.SNt == 0) or (self.RNt >= self.SNt):
          #             if self.Uqueue_tx:
          #                 packetinTX = self._appendCRC([0]+[self.SNt]+self.Uqueue_tx.popleft()) # not an ACK, SN?
          #                 print(f"{self.ID}:tx a packet.")
          #                 self.Lqueue_tx.append(packetinTX)
          #                 timer = 0
          #                 self.SNt += 1
          #         else:
          #             if self.ACKr == 111:
          #                 self.Lqueue_tx.append(packetinTX)
          #                 timer = 0
          #             elif timer > 5:  # replace with a real timer
          #                 print(f"{self.ID}:retransmitt a packet.")
          #                 self.Lqueue_tx.append(packetinTX)
          #                 timer = 0
          #             else:
          #                 pass # wait for ACK and noop until timer runs out
          #                 timer += 1
          #         time.sleep(0.01)

          def _StopWaitARQ(self):
              current_tx_packet = None
              tx_sent_time = 0.0
              while True:
                  while self.Lqueue_rx:
                      raw = self.Lqueue_rx.popleft()
                      packetinRX = self._checkCRC(raw)
                      if not packetinRX:
                          try:
                              src_from_raw = raw[7]
                          except Exception:
                              src_from_raw = None
                          if src_from_raw is not None:
                              nack = self._appendCRC([111, self.RNr, src_from_raw, self.ID])
                              self.Lqueue_txACK.append(nack)
                              print(f"{self.ID}: CRC Failed -> Sending NACK")
                          continue
                      ack = packetinRX[0]
                      num = packetinRX[1]
                      dest = packetinRX[2]
                      src  = packetinRX[3]
                      payload = packetinRX[4:]
                      if ack != 0:
                          if ack == 111:
                              print(f"{self.ID}: Received NACK -> Will Retransmit")
                              if current_tx_packet is not None:
                                  tx_sent_time = 0.0
                          else:
                              last_sent_sn = (self.SNt - 1) if self.SNt > 0 else 0
                              if num == last_sent_sn or num == self.RNt:
                                  print(f"{self.ID}: Received ACK({num})")
                                  current_tx_packet = None
                                  tx_sent_time = 0.0
                                  self.RNt = num
                                  self.ACKr = ack
                      else:
                          print(f"{self.ID}: Received MSG({num}) from {src}")
                          self.SNr = num
                          if self.SNr == self.RNr:
                              self.RNr += 1
                              self.Uqueue_rx.append([dest, src] + payload)
                              ACKpacket = self._appendCRC([1, self.SNr, src, self.ID])
                              print(f"{self.ID}: Sending ACK({self.SNr})")
                              self.Lqueue_txACK.append(ACKpacket)
                          else:
                              ack_num = max(0, self.RNr - 1)
                              ACKpacket = self._appendCRC([1, ack_num, src, self.ID])
                              print(f"{self.ID}: Out-of-order MSG -> Sending ACK({ack_num})")
                              self.Lqueue_txACK.append(ACKpacket)
                  if self.Lqueue_txACK:
                      print(f"{self.ID}: Transmitting ACK/NACK Frame")
                      self.Lqueue_tx.append(self.Lqueue_txACK.popleft())
                  if current_tx_packet is None and self.Uqueue_tx:
                      payload_frame = self.Uqueue_tx.popleft()
                      current_tx_packet = self._appendCRC([0, self.SNt] + payload_frame)
                      print(f"{self.ID}: Transmitting MSG({self.SNt})")
                      self.Lqueue_tx.append(current_tx_packet)
                      tx_sent_time = time.time()
                      self.SNt += 1
                  if current_tx_packet is not None:
                      if time.time() - tx_sent_time > self.timeout:
                          print(f"{self.ID}: TIMEOUT -> Retransmitting MSG")
                          self.Lqueue_tx.append(current_tx_packet)
                          tx_sent_time = time.time()
                  time.sleep(0.005)
          

          def _encrypt(self, msg):
              data = msg.encode('utf-8')
              pad_len = 16 - (len(data) % 16)
              padded = data + bytes([pad_len]) * pad_len
              iv = get_random_bytes(16)
              cipher = AES.new(self.key, AES.MODE_CBC, iv)
              ciphertext = cipher.encrypt(padded)

              return iv + ciphertext
          
          def _decrypt(self, encrypted_bytes):
              if isinstance(encrypted_bytes, list):
                  encrypted_bytes = bytes(encrypted_bytes)

              iv = encrypted_bytes[:16]
              ciphertext = encrypted_bytes[16:]
              cipher = AES.new(self.key, AES.MODE_CBC, iv)
              padded_plaintext = cipher.decrypt(ciphertext)
              pad_len = padded_plaintext[-1]
              if pad_len < 1 or pad_len > 16:
                  raise ValueError("Invalid padding")
              plaintext = padded_plaintext[:-pad_len]
              return plaintext.decode('utf-8')

          def _appendCRC(self, packet): # packet = [ack, num, dest, src, payload...]
              ack = packet[0]
              num = packet[1]
              dest = packet[2]
              src = packet[3]
              payload = packet[4:]
              payload_bytes = bytes(payload)
              data = bytes([ack, num, dest, src]) + payload_bytes
              crc = zlib.crc32(data)
              crc = [(crc >> 24) & 0xFF, (crc >> 16) & 0xFF, (crc >> 8) & 0xFF, crc & 0xFF]

              return crc + [ack, num, dest, src] + payload
          
          def _checkCRC(self, packet): # [CRC0, CRC1, CRC2, CRC3, ack, num, dest, src, payload...]
              crc_recv = ((packet[0] << 24) | (packet[1] << 16) | (packet[2] << 8) | packet[3])
              ack  = packet[4]
              num  = packet[5]
              dest = packet[6]
              src  = packet[7]
              payload = packet[8:]
              payload_bytes = bytes(payload)
              data = bytes([ack, num, dest, src]) + payload_bytes
              crc_calc = zlib.crc32(data)
              if crc_calc == crc_recv:
                  return [ack, num, dest, src] + payload
              else:
                  return False
          
          def _log_loop(self):
                  while True:
                      self.print_status()
                      time.sleep(0.5)

          def print_status(self):
              print(f"Node ID: {self.ID}")
              print(f"Key: {self.key}")
              print(f"Uqueue_tx: {list(self.Uqueue_tx)}")
              print(f"Uqueue_rx: {list(self.Uqueue_rx)}")
              print(f"Lqueue_tx: {list(self.Lqueue_tx)}")
              print(f"Lqueue_txACK: {list(self.Lqueue_txACK)}")
              print(f"Lqueue_rx: {list(self.Lqueue_rx)}")
              print(f"SNt: {self.SNt}, RNt: {self.RNt}")
              print(f"SNr: {self.SNr}, RNr: {self.RNr}")
              print(f"ACKr: {self.ACKr}")
              print("--------------------------------------------------")
              

      # SIMPLE GUI


      # from gnuradio import gr
      # import pmt
      # import threading
      # import queue
      # import time
      # from PyQt5 import QtWidgets, QtCore


      # class Messages(gr.basic_block):
      #     def __init__(self, nodeID=0x00, timeout = 1, key=b"0123456789abcdef"):
      #         gr.basic_block.__init__(self,
      #                                name="Messages",
      #                                in_sig=None,
      #                                out_sig=None)
      #         self.node = Node(nodeID, key, timeout, False)

      #         self.message_port_register_in(pmt.intern("in"))
      #         self.message_port_register_out(pmt.intern("out"))
      #         self.set_msg_handler(pmt.intern("in"), self.rx_from_phy)

      #         self.app = QtWidgets.QApplication.instance() or QtWidgets.QApplication([])
      #         self.window = self.GuiWindow(self)
      #         self.window.show()

      #         self.timer = QtCore.QTimer()
      #         self.timer.timeout.connect(self.poll_node)
      #         self.timer.start(10) #50

      #     def rx_from_phy(self, pdu):
      #         payload = list(pmt.u8vector_elements(pmt.cdr(pdu)))
      #         self.node.RXPacket(payload)

      #     def poll_node(self):
      #         while True:
      #             pkt = self.node.TXPacket()
      #             if pkt:
      #                 payload_pmt = pmt.init_u8vector(len(pkt), pkt)
      #                 pdu = pmt.cons(pmt.PMT_NIL, payload_pmt)
      #                 self.message_port_pub(pmt.intern("out"), pdu)
      #             else:
      #                 break

      #         while True:
      #             msg = self.node.dequeMsgRX()
      #             if not msg:
      #                 break
      #             src, msg_text = msg
      #             self.window.append_message(src, msg_text)

      #     class GuiWindow(QtWidgets.QWidget):
      #         def __init__(self, block):
      #             super().__init__()
      #             self.block = block
      #             self.setWindowTitle(f"Messages(ID={block.node.ID})")
      #             self.resize(650, 450)
      #             layout = QtWidgets.QVBoxLayout(self)

      #             self.text_incoming = QtWidgets.QTextEdit()
      #             self.text_incoming.setReadOnly(True)
      #             layout.addWidget(self.text_incoming)

      #             hl = QtWidgets.QHBoxLayout()
      #             hl.addWidget(QtWidgets.QLabel("Dest ID:"))
      #             self.dest_spin = QtWidgets.QSpinBox()
      #             self.dest_spin.setRange(0, 255)
      #             hl.addWidget(self.dest_spin)

      #             self.input_line = QtWidgets.QLineEdit()
      #             hl.addWidget(self.input_line, stretch=1)

      #             self.send_btn = QtWidgets.QPushButton("Send")
      #             hl.addWidget(self.send_btn)
      #             layout.addLayout(hl)

      #             self.send_btn.clicked.connect(self.send_message)
      #             self.input_line.returnPressed.connect(self.send_message)

      #         def send_message(self):
      #             msg = self.input_line.text().strip()
      #             if not msg:
      #                 return
      #             dest = self.dest_spin.value()
      #             self.block.node.enqueueMsgTX(dest, msg)
      #             self.input_line.clear()

      #         def append_message(self, src, msg):
      #             self.text_incoming.append(f"[From {src}] {msg}")




      from gnuradio import gr
      import pmt
      from PyQt5 import QtWidgets, QtCore, QtGui
      from datetime import datetime

      class Messages(gr.basic_block):
          def __init__(self, nodeID=0x00, timeout=1, key=b"0123456789abcdef"):
              super().__init__(name="Messages", in_sig=None, out_sig=None)
              self.node = Node(nodeID, key, timeout, False)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.rx_from_phy)

              self.app = QtWidgets.QApplication.instance() or QtWidgets.QApplication([])

              self.window = self.GuiWindow(self)
              self.window.show()

              self.timer = QtCore.QTimer()
              self.timer.timeout.connect(self.poll_node)
              self.timer.start(10)

          def rx_from_phy(self, pdu):
              payload = list(pmt.u8vector_elements(pmt.cdr(pdu)))
              self.node.RXPacket(payload)

          def poll_node(self):
              while True:
                  pkt = self.node.TXPacket()
                  if pkt:
                      payload_pmt = pmt.init_u8vector(len(pkt), pkt)
                      pdu = pmt.cons(pmt.PMT_NIL, payload_pmt)
                      self.message_port_pub(pmt.intern("out"), pdu)
                  else:
                      break

              while True:
                  msg = self.node.dequeMsgRX()
                  if not msg:
                      break
                  src, msg_text = msg
                  self.window.append_message(str(src), msg_text)


          class GuiWindow(QtWidgets.QWidget):
              def __init__(self, block):
                  super().__init__()
                  self.block = block
                  self.setWindowTitle(f"Messeges. User: {block.node.ID}")
                  self.resize(680, 600)
                  self.setStyleSheet("""
                      QWidget { background-color: #1a1a2e; color: #eaeaea; }
                  """)

                  main_layout = QtWidgets.QVBoxLayout(self)
                  main_layout.setContentsMargins(0,0,0,0)
                  main_layout.setSpacing(0)

                  header = QtWidgets.QWidget()
                  header.setStyleSheet("""
                      QWidget {
                          background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                              stop:0 #6a11cb, stop:1 #2575fc);
                          border-bottom: 2px solid #4a5568;
                      }
                  """)
                  header.setFixedHeight(70)
                  hl = QtWidgets.QHBoxLayout(header)
                  hl.setContentsMargins(20, 10, 20, 10)

                  label = QtWidgets.QLabel("To:")
                  label.setStyleSheet("font-size:16px; font-weight:bold; color:white;")
                  hl.addWidget(label)

                  self.dest_input = QtWidgets.QLineEdit()
                  self.dest_input.setPlaceholderText("Enter receiver (0-255)")
                  self.dest_input.setText(str(block.node.ID))
                  self.dest_input.setFixedWidth(300)
                  self.dest_input.setStyleSheet("""
                      QLineEdit {
                          background-color: rgba(255,255,255,0.15);
                          border: 2px solid rgba(255,255,255,0.3);
                          border-radius: 20px;
                          padding: 8px 15px;
                          font-size: 14px;
                          color: #ffffff;
                      }
                      QLineEdit:focus {
                          border: 2px solid #00d4ff;
                          background-color: rgba(255,255,255,0.25);
                      }
                  """)
                  hl.addWidget(self.dest_input)
                  hl.addStretch()

                  main_layout.addWidget(header)

                  self.scroll_area = QtWidgets.QScrollArea()
                  self.scroll_area.setWidgetResizable(True)
                  self.scroll_area.setStyleSheet("background-color:#16213e; border:none;")
                  main_layout.addWidget(self.scroll_area)

                  self.chat_container = QtWidgets.QWidget()
                  self.chat_layout = QtWidgets.QVBoxLayout(self.chat_container)
                  self.chat_layout.setAlignment(QtCore.Qt.AlignTop)
                  self.chat_layout.setSpacing(12)
                  self.chat_layout.setContentsMargins(15,15,15,15)
                  self.scroll_area.setWidget(self.chat_container)


                  input_bar = QtWidgets.QWidget()
                  input_bar.setFixedHeight(80)
                  input_bar.setStyleSheet("background-color:#0f3460; border-top:2px solid #4a5568;")
                  ib = QtWidgets.QHBoxLayout(input_bar)
                  ib.setContentsMargins(15,15,15,15)

                  self.input_line = QtWidgets.QLineEdit()
                  self.input_line.setPlaceholderText("Type your message...")
                  self.input_line.setStyleSheet("""
                      QLineEdit {
                          border: 2px solid #4a5568;
                          border-radius: 22px;
                          padding: 10px 18px;
                          background-color: #1a1a2e;
                          color: #eaeaea;
                          font-size: 15px;
                      }
                      QLineEdit:focus {
                          border: 2px solid #00d4ff;
                          background-color: #252545;
                      }
                  """)

                  self.send_btn = QtWidgets.QPushButton("Send")
                  self.send_btn.setFixedWidth(100)
                  self.send_btn.setStyleSheet("""
                      QPushButton {
                          background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                              stop:0 #f093fb, stop:1 #f5576c);
                          color: white;
                          border: none;
                          border-radius: 22px;
                          padding: 10px 20px;
                          font-weight: bold;
                          font-size: 15px;
                      }
                      QPushButton:hover {
                          background: qlineargradient(x1:0, y1:0, x2:1, y2:0,
                              stop:0 #fa709a, stop:1 #fee140);
                      }
                  """)

                  ib.addWidget(self.input_line)
                  ib.addWidget(self.send_btn)
                  main_layout.addWidget(input_bar)

                  self.send_btn.clicked.connect(self.send_message)
                  self.input_line.returnPressed.connect(self.send_message)


              def send_message(self):
                  text = self.input_line.text().strip()
                  if not text:
                      return

                  try:
                      dest = int(self.dest_input.text().strip())
                  except:
                      dest = 0

                  self.block.node.enqueueMsgTX(dest, text)
                  self.input_line.clear()

                  self._add_bubble(text, outgoing=True)


              def append_message(self, src, msg):
                  self._add_bubble(f"{msg}", sender=src, outgoing=False)


              def _add_bubble(self, text, sender=None, outgoing=False):
                  container = QtWidgets.QWidget()
                  container.setStyleSheet("background:transparent;")
                  vbox = QtWidgets.QVBoxLayout(container)
                  vbox.setContentsMargins(0,0,0,0)
                  vbox.setSpacing(4)

                  if sender is not None:
                      lab = QtWidgets.QLabel(str(sender))
                      lab.setStyleSheet("font-size:11px; color:#00d4ff; font-weight:bold;")
                      vbox.addWidget(lab, alignment=QtCore.Qt.AlignLeft)

                  scroll = QtWidgets.QScrollArea()
                  scroll.setWidgetResizable(True)
                  scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
                  scroll.setStyleSheet("background:transparent; border:none;")

                  bubble = QtWidgets.QLabel(text)
                  bubble.setWordWrap(False)
                  bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)

                  if outgoing:
                      bubble.setStyleSheet("""
                          QLabel {
                              background: qlineargradient(x1:0, y1:0, x2:1, y2:1,
                                  stop:0 #667eea, stop:1 #764ba2);
                              color: #ffffff;
                              border-radius: 18px;
                              padding: 12px 16px;
                              font-size: 14px;
                          }
                      """)
                  else:
                      bubble.setStyleSheet("""
                          QLabel {
                              background: qlineargradient(x1:0, y1:0, x2:1, y2:1,
                                  stop:0 #2c3e50, stop:1 #34495e);
                              color: #ecf0f1;
                              border-radius: 18px;
                              padding: 12px 16px;
                              font-size: 14px;
                              border: 1px solid #4a5568;
                          }
                      """)

                  scroll.setWidget(bubble)
                  scroll.setMinimumWidth(160)
                  scroll.setMaximumWidth(520)

                  align = QtCore.Qt.AlignRight if outgoing else QtCore.Qt.AlignLeft
                  vbox.addWidget(scroll, alignment=align)

                  self.chat_layout.addWidget(container, alignment=align)

                  QtWidgets.QApplication.processEvents()
                  QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                      self.scroll_area.verticalScrollBar().maximum()))
    key: b"0123456789abcdef"
    nodeID: '0x01'
    timeout: '0.01'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [blocks_repack_bits_bb_1_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0_0, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0_0, '0']
- [channels_channel_model_0_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0_0_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', digital_linear_equalizer_0_0_0_0, '0']
- [epy_block_0_1_0, out, digital_protocol_formatter_async_0, in]
- [epy_block_0_1_0_0, out, digital_protocol_formatter_async_0_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_0_1_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_block_0_1_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
